options:
  parameters:
    author: shiprect
    generate_options: qt_gui
    id: PSK_Transmitter
    output_language: python
    title: PSK_Transmitter
  states: {}

blocks:
- name: BB_Gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: Bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: ChanFreq
  id: variable
  parameters:
    value: '105000000'
  states: {}
- name: IF_Gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: PSK
  id: variable_constellation
  parameters:
    const_points: '[(-3-3j), (-1-3j), (1-3j), (3-3j), (-3-1j), (-1-1j), (1-1j), (3-1j), (-3+1j), (-1+1j), (1+1j), (3+1j), (-3+3j), (-1+3j), (1+3j), (3+3j)]'
    precision: '8'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: 8psk
  states: {}
- name: RF_Gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: RRC_Alpha
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: SampleRate
  id: variable
  parameters:
    value: SymbolRate*SamplesPerSymbol
  states: {}
- name: SamplesPerSymbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SymbolRate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '8'
    min: '0'
    num_samps: '8'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wastump42/Desktop/Will_Telecomm_GRC/sourcefile.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: PSK
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: '10000'
    freq0: ChanFreq
    gain0: '10'
    if_gain0: '20'
    sample_rate: SampleRate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"TX ConstellationSink"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: SampleRate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"TX FrequencySink"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"TX TimeSink"'
    size: '1024'
    srate: SampleRate
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: RRC_Alpha
    gain: SamplesPerSymbol
    interp: SamplesPerSymbol
    ntaps: 11*SamplesPerSymbol
    samp_rate: SampleRate
    sym_rate: SymbolRate
    type: interp_fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', osmosdr_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
