options:
  parameters:
    author: shiprect
    generate_options: qt_gui
    id: PolyphaseSync
    output_language: python
    title: PolyphaseSync
  states: {}

blocks:
- name: CenterFrequency
  id: variable_qtgui_range
  parameters:
    label: CenterFrequency
    start: 400e6
    step: 1e3
    stop: 450e6
    value: 425e6
  states: {}
- name: CostasLoop_BW
  id: variable_qtgui_range
  parameters:
    label: CostasLoop_BW
    start: '.0001'
    step: '.001'
    stop: '5'
    value: 2*3.1415*1e-3
  states: {}
- name: PSK
  id: variable_constellation
  parameters:
    const_points: '[0.92+0.38j, 0.38 + 0.92j, -0.38+0.92j, 0.-0.92+0.38j, -0.92-0.38j, -0.38-0.92j, 0.38-0.92j, 0.92-0.38j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[7, 6, 2, 3, 1, 0, 4, 5]'
    type: calcdist
  states: {}
- name: RRC_Alpha
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: SDR_Bandwidth
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: SDR_SampleRate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: SampleRate
  id: variable
  parameters:
    value: SymbolRate*SamplesPerSymbol
  states: {}
- name: SamplesPerSymbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SymbolRate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: SymbolSync_BW
  id: variable_qtgui_range
  parameters:
    label: SymbolSync_BW
    start: '.001'
    step: '.001'
    stop: '5'
    value: 2*3.1415*0.40
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(SamplesPerSymbol), 0.35, 45*nfilts)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: recv.txt
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '3'
    l: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: PSK
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: CostasLoop_BW
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '8'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    osps: '1'
    sps: SamplesPerSymbol
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: SymbolSync_BW
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: SamplesPerSymbol
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: SDR_Bandwidth
    freq0: CenterFrequency
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: SDR_SampleRate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    samp_per_symbol: SamplesPerSymbol
    size: '1024'
    srate: SampleRate
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: SDR_SampleRate
    ctrlpanel: 'True'
    fc: CenterFrequency
    fftsize: '1024'
    name: '"RX FrequencySink"'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: SDR_SampleRate
    fc: CenterFrequency
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: RRC_Alpha
    gain: '1'
    interp: '1'
    ntaps: 11*SamplesPerSymbol
    samp_rate: SampleRate
    sym_rate: SymbolRate
    type: interp_fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: SDR_Bandwidth
    freq0: CenterFrequency
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: SDR_SampleRate
    sync: sync
    type: fc32
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: CenterFrequency
    samp_rate: SDR_SampleRate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: PostSync
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RX_Channel_Sync
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RX_Channel_Synced
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: PostSync
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RX_Channel_Synced
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: RX_Channel_Sync
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_number_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_eye_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [virtual_source_0_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
